FILESEXTRAPATHS_prepend := "${THISDIR}/qtdeclarative-${PV}:"

SRC_URI += " \
	file://0001-add_tracepoint_layer.patch \
	"
